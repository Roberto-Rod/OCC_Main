# IAR project arm1_dev_kit_cm7.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1176DVMAA_cm7; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; TX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ..\source; ..\..\board; ..\..\common; C:\SDK_2_11_0_MIMXRT1170-EVK\devices\MIMXRT1176\utilities\debug_console_lite; C:\SDK_2_11_0_MIMXRT1170-EVK\devices\MIMXRT1176\drivers; C:\SDK_2_11_0_MIMXRT1170-EVK\devices\MIMXRT1176; C:\SDK_2_11_0_MIMXRT1170-EVK\components\uart; C:\SDK_2_11_0_MIMXRT1170-EVK\components\lists; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\camera; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\camera\device; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\camera\device\ov5640; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\camera\device\sccb; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\camera\receiver; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\camera\receiver\csi; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\display; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\display\dc; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\display\dc\lcdifv2; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\display\mipi_dsi_cmd; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\display\rm68200; C:\SDK_2_11_0_MIMXRT1170-EVK\components\osa; C:\SDK_2_11_0_MIMXRT1170-EVK\middleware\usb\include; C:\SDK_2_11_0_MIMXRT1170-EVK\middleware\usb\phy; C:\SDK_2_11_0_MIMXRT1170-EVK\devices\MIMXRT1176\xip; ..\..\..\..\xip; C:\SDK_2_11_0_MIMXRT1170-EVK\devices\MIMXRT1176\drivers\cm7; C:\SDK_2_11_0_MIMXRT1170-EVK\CMSIS\Core\Include; ../../../../../../threadx/common/inc; ../../../../../../threadx/ports/cortex_m7/iar/inc; ../../../../../../usbx/common/core/inc; ../../../../../../usbx/common/usbx_device_classes/inc; ../../../../../../usbx/ports/cortex_m7/iar/inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: arm1_dev_kit_cm7.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  ILINK.IlinkAdditionalLibs: debug\Exe\tx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; TX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkAdditionalLibs: release\Exe\tx.a
configuration flexspi_nor_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; TX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; TX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  ILINK.IlinkAdditionalLibs: release\Exe\tx.a
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; TX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; TX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: release\Exe\tx.a
configuration flexspi_nor_multicore_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CORE1_IMAGE_COPY_TO_RAM; CPU_MIMXRT1176DVMAA_cm7; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; TX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; MULTICORE_APP=1; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: ..; ..\source; ..\..\board; ..\..\common; C:\SDK_2_11_0_MIMXRT1170-EVK\devices\MIMXRT1176\utilities\debug_console_lite; C:\SDK_2_11_0_MIMXRT1170-EVK\devices\MIMXRT1176\drivers; C:\SDK_2_11_0_MIMXRT1170-EVK\devices\MIMXRT1176; C:\SDK_2_11_0_MIMXRT1170-EVK\components\uart; C:\SDK_2_11_0_MIMXRT1170-EVK\components\lists; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\camera; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\camera\device; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\camera\device\ov5640; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\camera\device\sccb; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\camera\receiver; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\camera\receiver\csi; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\display; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\display\dc; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\display\dc\lcdifv2; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\display\mipi_dsi_cmd; C:\SDK_2_11_0_MIMXRT1170-EVK\components\video\display\rm68200; C:\SDK_2_11_0_MIMXRT1170-EVK\components\osa; C:\SDK_2_11_0_MIMXRT1170-EVK\middleware\usb\include; C:\SDK_2_11_0_MIMXRT1170-EVK\middleware\usb\phy; C:\SDK_2_11_0_MIMXRT1170-EVK\devices\MIMXRT1176\xip; ..\..\..\..\xip; C:\SDK_2_11_0_MIMXRT1170-EVK\devices\MIMXRT1176\drivers\cm7; C:\SDK_2_11_0_MIMXRT1170-EVK\CMSIS\Core\Include; C:\SDK_2_11_0_MIMXRT1170-EVK\middleware\multicore\mcmgr\src; ../../../../../../threadx/common/inc; ../../../../../../threadx/ports/cortex_m7/iar/inc; ../../../../../../usbx/common/core/inc; ../../../../../../usbx/common/usbx_device_classes/inc; ../../../../../../usbx/ports/cortex_m7/iar/inc
  OBJCOPY.OOCOutputFile: arm1_dev_kit_cm7.srec
  ILINK.IlinkKeepSymbols: _arm1_dev_kit_cm4_image
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  group azure-rtos
    ../source/: tx_api.c tx_initialize_low_level.c
  group azure-rtos/config
    ../source/: tx_user.h ux_user.h
  group azure-rtos/usbx/common/core/inc
    ../../../../../../usbx/common/core/inc/: ux_api.h ux_dcd_sim_slave.h ux_device_class_dpump.h ux_device_stack.h ux_hcd_sim_host.h ux_host_class_dpump.h ux_host_stack.h ux_system.h ux_user_sample.h ux_utility.h
  group azure-rtos/usbx/common/core/src
    ../../../../../../usbx/common/core/src/: ux_dcd_sim_slave_address_set.c ux_dcd_sim_slave_endpoint_create.c ux_dcd_sim_slave_endpoint_destroy.c ux_dcd_sim_slave_endpoint_reset.c ux_dcd_sim_slave_endpoint_stall.c ux_dcd_sim_slave_endpoint_status.c ux_dcd_sim_slave_frame_number_get.c ux_dcd_sim_slave_function.c ux_dcd_sim_slave_initialize.c ux_dcd_sim_slave_initialize_complete.c ux_dcd_sim_slave_state_change.c ux_dcd_sim_slave_transfer_abort.c ux_dcd_sim_slave_transfer_request.c ux_device_class_dpump_activate.c ux_device_class_dpump_change.c ux_device_class_dpump_deactivate.c ux_device_class_dpump_entry.c ux_device_class_dpump_initialize.c ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_set_feature.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_hcd_sim_host_asynch_queue_process.c ux_hcd_sim_host_asynch_schedule.c ux_hcd_sim_host_asynchronous_endpoint_create.c ux_hcd_sim_host_asynchronous_endpoint_destroy.c ux_hcd_sim_host_controller_disable.c ux_hcd_sim_host_ed_obtain.c ux_hcd_sim_host_ed_td_clean.c ux_hcd_sim_host_endpoint_reset.c ux_hcd_sim_host_entry.c ux_hcd_sim_host_frame_number_get.c ux_hcd_sim_host_frame_number_set.c ux_hcd_sim_host_initialize.c ux_hcd_sim_host_interrupt_endpoint_create.c ux_hcd_sim_host_iso_queue_process.c ux_hcd_sim_host_iso_schedule.c ux_hcd_sim_host_isochronous_endpoint_create.c ux_hcd_sim_host_isochronous_td_obtain.c ux_hcd_sim_host_least_traffic_list_get.c ux_hcd_sim_host_periodic_endpoint_destroy.c ux_hcd_sim_host_periodic_schedule.c ux_hcd_sim_host_periodic_tree_create.c ux_hcd_sim_host_port_reset.c ux_hcd_sim_host_port_status_get.c ux_hcd_sim_host_regular_td_obtain.c ux_hcd_sim_host_request_bulk_transfer.c ux_hcd_sim_host_request_control_transfer.c ux_hcd_sim_host_request_interupt_transfer.c ux_hcd_sim_host_request_isochronous_transfer.c ux_hcd_sim_host_request_transfer.c ux_hcd_sim_host_timer_function.c ux_hcd_sim_host_transaction_schedule.c ux_hcd_sim_host_transfer_abort.c ux_hcd_sim_host_transfer_run.c ux_hcd_sim_host_uninitialize.c ux_host_class_dpump_activate.c ux_host_class_dpump_configure.c ux_host_class_dpump_deactivate.c ux_host_class_dpump_endpoints_get.c ux_host_class_dpump_entry.c ux_host_stack_bandwidth_check.c ux_host_stack_bandwidth_claim.c ux_host_stack_bandwidth_release.c ux_host_stack_class_call.c ux_host_stack_class_device_scan.c ux_host_stack_class_get.c ux_host_stack_class_instance_create.c ux_host_stack_class_instance_destroy.c ux_host_stack_class_instance_get.c ux_host_stack_class_instance_verify.c ux_host_stack_class_interface_scan.c ux_host_stack_class_register.c ux_host_stack_class_unregister.c ux_host_stack_configuration_descriptor_parse.c ux_host_stack_configuration_enumerate.c ux_host_stack_configuration_instance_create.c ux_host_stack_configuration_instance_delete.c ux_host_stack_configuration_interface_get.c ux_host_stack_configuration_interface_scan.c ux_host_stack_configuration_set.c ux_host_stack_delay_ms.c ux_host_stack_device_address_set.c ux_host_stack_device_configuration_activate.c ux_host_stack_device_configuration_deactivate.c ux_host_stack_device_configuration_get.c ux_host_stack_device_configuration_reset.c ux_host_stack_device_configuration_select.c ux_host_stack_device_descriptor_read.c ux_host_stack_device_get.c ux_host_stack_device_remove.c ux_host_stack_device_resources_free.c ux_host_stack_device_string_get.c ux_host_stack_endpoint_instance_create.c ux_host_stack_endpoint_instance_delete.c ux_host_stack_endpoint_reset.c ux_host_stack_endpoint_transfer_abort.c ux_host_stack_enum_thread_entry.c ux_host_stack_hcd_register.c ux_host_stack_hcd_thread_entry.c ux_host_stack_hcd_transfer_request.c ux_host_stack_hcd_unregister.c ux_host_stack_hnp_polling_thread_entry.c ux_host_stack_initialize.c ux_host_stack_interface_endpoint_get.c ux_host_stack_interface_instance_create.c ux_host_stack_interface_instance_delete.c ux_host_stack_interface_set.c ux_host_stack_interface_setting_select.c ux_host_stack_interfaces_scan.c ux_host_stack_new_configuration_create.c ux_host_stack_new_device_create.c ux_host_stack_new_device_get.c ux_host_stack_new_endpoint_create.c ux_host_stack_new_interface_create.c ux_host_stack_rh_change_process.c ux_host_stack_rh_device_extraction.c ux_host_stack_rh_device_insertion.c ux_host_stack_role_swap.c ux_host_stack_tasks_run.c ux_host_stack_transfer_request.c ux_host_stack_transfer_request_abort.c ux_host_stack_transfer_run.c ux_host_stack_uninitialize.c ux_system_error_handler.c ux_system_initialize.c ux_utility_delay_ms.c ux_utility_descriptor_parse.c ux_utility_long_get.c ux_utility_memory_allocate.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_short_get.c ux_utility_short_put.c ux_utility_string_length_check.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_timer_create.c ux_utility_timer_delete.c
  group azure-rtos/usbx/ports/cortex_m7/iar/inc
    ../../../../../../usbx/ports/cortex_m7/iar/inc/: ux_port.h
  group board
    ../../board/: board.c board.h camera_support.c camera_support.h clock_config.c clock_config.h dcd.c dcd.h display_support.c display_support.h fpga.c fpga.h pin_mux.c pin_mux.h
  group board/i2c
    ../../board/: ad5246.c ad5246.h ad5667r.c ad5667r.h i2c.c i2c.h lis2de12.c lis2de12.h max17059.c max17059.h mp2672.c mp2672.h ovm9724.c ovm9724.h pca8574.c pca8574.h pca9530.c pca9530.h stts22h.c stts22h.h stts75.c stts75.h
  group board/mipi
    ../../board/: st7701s.c st7701s.h
  group board/semc
    ../../board/: semc.c semc.h
  group board/spi
    ../../board/: adc36xx.c adc36xx.h spi.c spi.h
  group board/usb
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/middleware/usb/include/: usb.h usb_misc.h usb_spec.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/middleware/usb/phy/: usb_phy.c usb_phy.h
  group CMSIS
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group common
    ../../common/: core.c core.h
  group component/fxos8700cq
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/fxos8700cq/: fsl_fxos.c fsl_fxos.h
  group component/lists
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group component/uart
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group component/video
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/video/camera/: fsl_camera.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/video/camera/device/: fsl_camera_device.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/video/camera/receiver/csi/: fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.c fsl_dc_fb_lcdifv2.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/video/display/: fsl_display.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.c fsl_mipi_dsi_cmd.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/video/camera/device/ov5640/: fsl_ov5640.c fsl_ov5640.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/video/display/rm68200/: fsl_rm68200.c fsl_rm68200.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/video/camera/device/sccb/: fsl_sccb.c fsl_sccb.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/video/: fsl_video_common.c fsl_video_common.h
  group device
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_csi.c fsl_csi.h fsl_dcdc.c fsl_dcdc.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_enc.c fsl_enc.h fsl_flexio.c fsl_flexio.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lcdifv2.c fsl_lcdifv2.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpspi.c fsl_lpspi.h fsl_lpuart.c fsl_lpuart.h fsl_mipi_csi2rx.c fsl_mipi_csi2rx.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_mu.c fsl_mu.h fsl_pmu.c fsl_pmu.h fsl_pxp.c fsl_pxp.h fsl_semc.c fsl_semc.h fsl_soc_mipi_csi2rx.c fsl_soc_mipi_csi2rx.h fsl_soc_src.c fsl_soc_src.h fsl_xbara.c fsl_xbara.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm7side.jlinkscript
    ../../../../: project.yml
  group mcmgr
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/middleware/multicore/mcmgr/src/: mcmgr.c mcmgr.h mcmgr_internal_core_api.h mcmgr_internal_core_api_imxrt1170.c mcmgr_mu_internal.c
  group source
    ../source/: camera.c camera.h cmd.c cmd.h debug.c debug.h display.c display.h dma.c dma.h main.c pxp.c pxp.h qdc.c qdc.h video.c video.h
  group startup
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group utilities
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
  group xip
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
