<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\arm1_dev_kit_cm4.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>hello_world_cm4</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>hello_world_cm4</project>
                <configuration>debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>release</name>
            <member>
                <project>hello_world_cm4</project>
                <configuration>release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>debug</name>
            <member>
                <project>hello_world_cm4</project>
                <configuration>debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
