# IAR project arm1_dev_kit_cm4.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M4 NXP MIMXRT1176xxxA_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1176DVMAA_cm4; FLEXSPI_IN_USE; MULTICORE_APP=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../board; ../../common; C:/SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/utilities/debug_console_lite; C:/SDK_2_11_0_MIMXRT1170-EVK/middleware/multicore/mcmgr/src; C:/SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/drivers; C:/SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176; C:/SDK_2_11_0_MIMXRT1170-EVK/components/uart; C:/SDK_2_11_0_MIMXRT1170-EVK/components/lists; C:/SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/xip; ../../../../xip; C:/SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/drivers/cm4; C:/SDK_2_11_0_MIMXRT1170-EVK/CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: arm1_dev_kit_cm4.bin
  ILINK.IlinkOutputFile: arm1_dev_kit_cm4.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm4_ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1176DVMAA_cm4; FLEXSPI_IN_USE; MCMGR_HANDLE_EXCEPTIONS=1; __SEMIHOST_HARDFAULT_DISABLE=1; MULTICORE_APP=1; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../middleware/multicore/mcmgr/src; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../devices/MIMXRT1176; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../../../devices/MIMXRT1176/drivers/cm4; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: hello_world_cm4.out
  group board
    ../../board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group common
    ../../common/: core.c core.h
  group component/lists
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm4.h MIMXRT1176_cm4_features.h system_MIMXRT1176_cm4.c system_MIMXRT1176_cm4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_mu.c fsl_mu.h fsl_pmu.c fsl_pmu.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/drivers/cm4/: fsl_cache.c fsl_cache.h
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm4side.jlinkscript
  group mcmgr
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/middleware/multicore/mcmgr/src/: mcmgr.c mcmgr.h mcmgr_internal_core_api.h mcmgr_internal_core_api_imxrt1170.c mcmgr_mu_internal.c
  group source
    ../: main.c
  group startup
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm4.s
  group utilities
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
  group xip
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
    ../../../../../../../../SDK_2_11_0_MIMXRT1170-EVK/devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
